# Keil uVision project Project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Library;.\Start;.\App;.\Hardware;.\System;.\Hardware\LCD;.\Hardware\LCD_SPI;.\Hardware\TOUCH;.\System\LCD_delay;.\System\sys;.\App\LCD;.\Hardware\LED;.\Hardware\Usart;.\System\LCD_Timer;.\Hardware\LVGL;.\Hardware\LVGL\examples\porting;.\Hardware\LVGL\src;.\App\LVGL_myGui\patches;.\App\LVGL_myGui\src\custom;.\App\LVGL_myGui\src\generated;.\Hardware\FreeRTOS\include;.\Hardware\FreeRTOS\portable\MemMang;.\Hardware\FreeRTOS\portable\RVDS\ARM_CM4F;.\Hardware\FreeRTOS;.\Hardware\AHT10;.\Hardware\I2C;.\Hardware\FATFS;.\Hardware\LVGL\src\font;.\Hardware\LVGL\src\extra\libs\fsdrv;.\Hardware\Micro_SD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.h
    ./: Target_1.c
  group Library
    ./Library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group Hardware
    ./Hardware/LCD/: FONT.H lcd.c lcd.h
    ./Hardware/TOUCH/: ctpiic.c ctpiic.h ft6336.c ft6336.h touch.c touch.h
    ./Hardware/LCD_SPI/: LCD_SPI.c LCD_SPI.h
    ./Hardware/Usart/: Usart.c Usart.h
    ./Hardware/LED/: led.c led.h
    ./Hardware/AHT10/: AHT10.c AHT10.h
    ./Hardware/I2C/: MyI2C.c MyI2C.h
    ./Hardware/FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h
    ./Hardware/Micro_SD/: sd_port_user_template.c fatfs_diskio_bridge.c sd_fatfs_port.c sd_font_storage_fatfs.c fatfs_diskio_bridge.h sd_fatfs_port.h sd_font_storage_fatfs.h sd_port_user_template.h
  group System
    ./System/sys/: sys.c sys.h
    ./System/LCD_delay/: LCD_delay.c LCD_delay.h
    ./System/LCD_Timer/: LCD_Timer.c LCD_Timer.h
  group App
    ./App/LCD/: GUI.c GUI.h LCD_test.c LCD_test.h pic.h
  group FreeRTOS
    ./Hardware/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOSConfig.h
    ./Hardware/FreeRTOS/portable/MemMang/: heap_4.c
    ./Hardware/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group LVGL_src
    ./Hardware/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./Hardware/LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ./Hardware/LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ./Hardware/LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ./Hardware/LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ./Hardware/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./Hardware/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./Hardware/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./Hardware/LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ./Hardware/LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./Hardware/LVGL/src/extra/layouts/flex/: lv_flex.c
    ./Hardware/LVGL/src/extra/layouts/grid/: lv_grid.c
    ./Hardware/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ./Hardware/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./Hardware/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ./Hardware/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./Hardware/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./Hardware/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ./Hardware/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./Hardware/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ./Hardware/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./Hardware/LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ./Hardware/LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./Hardware/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ./Hardware/LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ./Hardware/LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ./Hardware/LVGL/src/extra/others/monkey/: lv_monkey.c
    ./Hardware/LVGL/src/extra/others/msg/: lv_msg.c
    ./Hardware/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ./Hardware/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ./Hardware/LVGL/src/extra/themes/default/: lv_theme_default.c
    ./Hardware/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ./Hardware/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ./Hardware/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./Hardware/LVGL/src/extra/widgets/chart/: lv_chart.c
    ./Hardware/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./Hardware/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./Hardware/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ./Hardware/LVGL/src/extra/widgets/led/: lv_led.c
    ./Hardware/LVGL/src/extra/widgets/list/: lv_list.c
    ./Hardware/LVGL/src/extra/widgets/menu/: lv_menu.c
    ./Hardware/LVGL/src/extra/widgets/meter/: lv_meter.c
    ./Hardware/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ./Hardware/LVGL/src/extra/widgets/span/: lv_span.c
    ./Hardware/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ./Hardware/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ./Hardware/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ./Hardware/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ./Hardware/LVGL/src/extra/widgets/win/: lv_win.c
    ./Hardware/LVGL/src/extra/: lv_extra.c
    ./Hardware/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./Hardware/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./Hardware/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./Hardware/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_myGui
    ./App/LVGL_myGui/src/custom/: custom.c custom.h lv_conf_ext.h
    ./App/LVGL_myGui/src/generated/: setup_scr_screen_1.c gui_guider.h events_init.c events_init.h gui_guider.c widgets_init.c widgets_init.h weather_display.c weather_display.h ui_env_display.c ui_env_display.h ui_time_display.c ui_time_display.h esp32_ui_controller.c esp32_ui_controller.h
    ./App/LVGL_myGui/src/generated/images/: _Celsius_alpha_20x20.c _Celsius_alpha_25x25.c _high_alpha_30x50.c _humidity_alpha_30x30.c _low_alpha_30x50.c _percentage_alpha_26x26.c _temperature_alpha_40x40.c _WIFI_alpha_20x20.c images_md5.json
    ./App/LVGL_myGui/src/generated/guider_customer_fonts/: guider_customer_fonts.h
    ./App/LVGL_myGui/src/generated/guider_fonts/: lv_font_Alatsi_Regular_25.c lv_font_Alatsi_Regular_30.c lv_font_Alatsi_Regular_50.c lv_font_Alatsi_Regular_75.c lv_font_Antonio_Regular_25.c lv_font_SourceHanSerifSC_Regular_12.c lv_font_SourceHanSerifSC_Regular_17.c lv_font_SourceHanSerifSC_Regular_30.c lv_font_WeekdayCN_Subset_30.c
  group LVGL_conf
    ./Hardware/LVGL/: lv_conf.h lvgl.h
  group LVGL_porting
    ./Hardware/LVGL/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_fs.c lv_port_fs.h lv_port_indev.c lv_port_indev.h
  group User
    ./User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
