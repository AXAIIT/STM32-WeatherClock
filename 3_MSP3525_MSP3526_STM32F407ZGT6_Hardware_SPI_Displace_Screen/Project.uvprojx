# Keil uVision project Project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Library;.\Start;.\App;.\Hardware;.\System;.\Hardware\LCD;.\Hardware\LCD_SPI;.\Hardware\TOUCH;.\System\LCD_delay;.\System\sys;.\App\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Start
    ./Start/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.h
  group Library
    ./Library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_cec.c stm32f4xx_cec.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dfsdm.c stm32f4xx_dfsdm.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_dsi.c stm32f4xx_dsi.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fmpi2c.c stm32f4xx_fmpi2c.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_lptim.c stm32f4xx_lptim.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_qspi.c stm32f4xx_qspi.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spdifrx.c stm32f4xx_spdifrx.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group Hardware
    ./Hardware/LCD/: FONT.H lcd.c lcd.h
    ./Hardware/TOUCH/: ctpiic.c ctpiic.h ft6336.c ft6336.h touch.c touch.h
    ./Hardware/LCD_SPI/: LCD_SPI.c LCD_SPI.h
  group System
    ./System/sys/: sys.c sys.h
    ./System/LCD_delay/: LCD_delay.c LCD_delay.h
  group App
    ./App/LCD/: GUI.c GUI.h LCD_test.c LCD_test.h pic.h
  group User
    ./User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
